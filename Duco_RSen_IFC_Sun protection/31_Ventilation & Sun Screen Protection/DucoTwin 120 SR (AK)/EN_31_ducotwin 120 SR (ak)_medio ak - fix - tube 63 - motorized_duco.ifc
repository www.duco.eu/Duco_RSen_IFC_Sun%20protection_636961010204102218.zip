Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T23:59:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 23:59:18 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{AE196E80-E513-4E02-BB43-65D4F74CFF74}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 23:58:49 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 23:58:50 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 23:58:50 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: fix_duco_ducotwin 120 (2)
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: RSen_h4_aluminium
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Construction(Type) - WT_V Fix: yes; WT_V Standard: no
Type - Identity Data(Type) - Assembly Code: 31.2; Manufacturer: Duco; RSen_C_code_ETIM: Transfer air grille; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 26/02/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V4; RSen_C_description: duco_window ventilation_ducotwin 120_fix; RSen_C_revit_version: 2016; Type Name: fix_duco_ducotwin 120; URL: http://www.duco.eu/producten/; WT_I BaseKeynote: 31.2
Type - Other(Type) - Category: Air Terminals; Family Name: GEO_DucoTwin 120_geleiders
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: fix_duco_ducotwin 120
Constraints - Moves With Nearby Elements: no
Dimensions - Area: 1.05092 m2; Volume: 0.000942281 m3; WT_V Length: 1800 mm
Materials and Finishes - RSen_C_material: RSen_h4_aluminium
Other - Category: Air Terminals; Family: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120; Family and Type: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120; Type: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120; Type Id: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/families
Name (GEO_DucoTwin 120_geleiders:fix_duco_ducotwin 120:...) | Mark
209774 | 231
209775 | 232

# IfcFlowTerminal: medio ak - fix - tube 63 - motorized_duco_ducotwin 120 SR (ak), RSen_31_AIR_FB_window ventilation - ducotwin 120 SR (ak)_duco:medio ak - fix - tube 63 - motorized_duco_ducotwin 120 SR (ak):209772
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: RSen_h4_aluminium, RSen_n_plastic_black, RSen_a_perforated, Linen, White
Type - Constraints(Type) - Default Elevation: 1500 mm; ZZZ_Afstand tussen zonwering_Exterior_Length: 44 mm; ZZZ_cutout bottom_height_Length: 58.5 mm; ZZZ_cutouts_height_Length: 145 mm; ZZZ_cutouts_height2_Length: 145 mm; ZZZ_cutout top_height_Length: 0 mm; ZZZ_end caps_length_Length: 35 mm; ZZZ_installation on window_YesNo: yes; ZZZ_length arrow_Length: 447 mm; ZZZ_side conductor_depth_Length: 69 mm; ZZZ_side conductor_width_Length: 33 mm; ZZZ_sunscreen_YesNo: yes
Type - Construction(Type) - WT_V Guides_type: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120; WT_V Outer grille_depth: 69 mm
Type - Dimensions(Type) - RSen_C_depth: 247 mm; RSen_C_height: 178.5 mm; WT_V Height grille: 120 mm
Type - Identity Data(Type) - Assembly Code: 31.2; Manufacturer: Duco; Model: DucoTwin 120; OmniClass Number: 3A(57.16.11); RSen_C_code_article: Medio AK/Fix-Tube 63/Motorized; RSen_C_code_ETIM: Transfer air grille; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; RSen_C_code_gtin: -; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 26/02/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V4; RSen_C_description: duco_window ventilation_ducotwin 120 SR (ak)_medio ak - fix - Tube 63 - Motorized; RSen_C_model: DucoTwin 120; RSen_C_revit_version: 2016; RSen_C_type: -; Type Name: medio ak - fix - tube 63 - motorized_duco_ducotwin 120 SR (ak); URL: http://www.duco.eu/producten/product.cfm?prod=230&pid=3-28&cat=28; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - RSen_C_material: RSen_h4_aluminium; WT_V End caps_material: RSen_n_plastic_black; WT_V Grille_material: RSen_a_perforated; WT_V Inner Profile_material: RSen_h4_aluminium; WT_V outer profile_material: RSen_h4_aluminium; WT_V Sun protection_material: Linen, White
Type - Mechanical - Flow(Type) - WT_I Ventilation capacity 10Pa: 0.759265 m3/s; WT_I Ventilation capacity 2Pa: 0.63174 m3/s
Type - Model Properties(Type) - WT_I Cap_sun protection on extension arm: no; WT_I Color: SAA - RAL - Bicolor; WT_I Maximum length grille under warranty: 3400 mm; WT_I Maximum ton/flap length under warranty: 2000 mm; WT_I Sound level difference Dne, W_in open position: 39 dB; WT_I Sun protection_manual: no; WT_I Sun protection_maximum height: 3000 mm; WT_I Sun protection_maximum width: 3400 mm; WT_I Sun protection_motorised: yes; WT_I Sun protection_surface: 7.5 m2; WT_I Tube 50: no; WT_I Tube 63: yes; WT_I Tube 78: no; WT_I Watertightness_in closed position: 1250 Pa; WT_I Window_MAX depth: 135 mm; WT_I Windtightness_in closed position: 450 Pa
Type - Other(Type) - Category: Air Terminals; Family Name: RSen_31_AIR_FB_window ventilation - ducotwin 120 SR (ak)_duco
Type - Text(Type) - WT_I Revit manual: http://www.witas.be/niko
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: medio ak - fix - tube 63 - motorized_duco_ducotwin 120 SR (ak)
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; ZZZ_cutouts_length_Length: 1000 mm; ZZZ_side conductor_height_Length: 1800 mm; ZZZ_Terminal interior_depth_Length: 98 mm; ZZZ_Terminal interior_length_Length: 930 mm; ZZZ_window of glass_depth_Length: 80 mm
Construction - WT_V Side guide_hauteur: 1800 mm; WT_V Sun protection_control: RSen_31_GM_FB_sun protection screen control_duco: profilemotor with button control_duco_sun protection screen control; WT_V Sun protection_opening length: 500 mm; WT_V Ventilator_control: RSen_31_GM_FB_ventilation vent control_duco: handle_short_duco_control ventilation grille; WT_V Window_depth: 80 mm
Dimensions - Area: 1.2946 m2; RSen_C_length: 1000 mm; Volume: 0.0390523 m3
Identity Data - Mark: 229
Mechanical - Flow - BE_M_pressure_difference_10Pa: no; BE_M_pressure_difference_2Pa: yes; RSen_M_flow_rate: 0.587518 m3/s
Model Properties - WT_I Under warranty: Ja
Other - Category: Air Terminals; Family: RSen_31_AIR_FB_window ventilation - ducotwin 120 SR (ak)_duco: medio ak - fix - tube 63 - motorized_duco_ducotwin 120 SR (ak); Family and Type: RSen_31_AIR_FB_window ventilation - ducotwin 120 SR (ak)_duco: medio ak - fix - tube 63 - motorized_duco_ducotwin 120 SR (ak); Schedule Level: Level: Level 1; Type: RSen_31_AIR_FB_window ventilation - ducotwin 120 SR (ak)_duco: medio ak - fix - tube 63 - motorized_duco_ducotwin 120 SR (ak); Type Id: RSen_31_AIR_FB_window ventilation - ducotwin 120 SR (ak)_duco: medio ak - fix - tube 63 - motorized_duco_ducotwin 120 SR (ak)
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/families
