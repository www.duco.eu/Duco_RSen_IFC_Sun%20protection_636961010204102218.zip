Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T01:25:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 01:25:35 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{655F3918-299C-4699-9409-EC0B83B122BD}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 01:25:32 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 01:25:32 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 01:25:32 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcBuildingElementProxy: fix - tube 78_duco_ducoscreen front 150, RSen_31_GM_FB_sunscreen - ducoscreen front 150_duco:fix - tube 78_duco_ducoscreen front 150:209100
In: Level 1
Type - Classification: 31.2 (Uniformat); Material: RSen_h4_aluminium, Linen, White
Type - Constraints(Type) - Default Elevation: 1500 mm; WT_H Conductor_type: RSen_31_GM_FB_conductor - SH_duco: fix_duco_ducoscreen front 150; ZZZ_Afstand tussen zonwering_Exterior_Length: 0 mm; ZZZ_cutout bottom_height_Length: 0 mm; ZZZ_cutouts_height_Length: 150 mm; ZZZ_cutouts_height2_Length: 150 mm; ZZZ_cutout top_height_Length: 0 mm; ZZZ_end caps_length_Length: 2 mm; ZZZ_installation on window_YesNo: yes; ZZZ_length arrow_Length: 310 mm; ZZZ_side conductor_depth_Length: 110 mm; ZZZ_side conductor_width_Length: 36 mm; ZZZ_sunscreen_YesNo: yes; ZZZ_Terminal exterior_depth_Length: 110 mm
Type - Dimensions(Type) - RSen_C_depth: 110 mm; RSen_C_height: 150 mm
Type - Identity Data(Type) - Assembly Code: 31.2; Description: duco_ducoscreen front 150_fix; Manufacturer: Duco; Model: DucoScreen Front 150; OmniClass Number: 3A(57.16.11); RSen_C_code_article: DucoScreen Front 150_fix; RSen_C_code_ETIM: Blinds; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC003229&classVersion=1; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 22/04/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V1; RSen_C_description: duco_ducoscreen front 150_fix; RSen_C_model: DucoScreen Front 150; RSen_C_revit_version: 2016; RSen_C_type: fix; RSen_C_type_comments: sunscreen; Type Comments: sunscreen; Type Name: fix - tube 78_duco_ducoscreen front 150; URL: http://www.duco.eu/producten/; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - RSen_C_material: RSen_h4_aluminium; WT_V Endcap_material: RSen_h4_aluminium; WT_V Sunscreen_material: Linen, White
Type - Model Properties(Type) - WT_I Color: -; WT_I Maximum height: 3000 mm; WT_I Maximum width: 4000 mm; WT_I Minimum width: 100 mm; WT_I Sun protection_manual: no; WT_I Sun protection_motorised: yes; WT_I Sun protection_surface: 12 m2; WT_I Tube 63: no; WT_I Tube 75: no; WT_I Tube 78: yes
Type - Other(Type) - Category: Generic Models; Family Name: RSen_31_GM_FB_sunscreen - ducoscreen front 150_duco
Pset_BuildingElementProxyCommon - Reference: fix - tube 78_duco_ducoscreen front 150
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; ZZZ_cutouts_length_Length: 1200 mm; ZZZ_side conductor_height_Length: 1200 mm; ZZZ_Terminal interior_depth_Length: 0 mm; ZZZ_Terminal interior_length_Length: 1196 mm
Construction - WT_V Conductor_height: 1200 mm; WT_V Endcap_inclined conductor: yes; WT_V Flat conductor_endcap: no; WT_V Sunscreen_control: RSen_31_GM_FB_sunscreen control - SH_duco: profilemotor with remote control_duco_sun protection screen control; WT_V Sunscreen_opening length: 500 mm; WT_V Unroll on outside: yes; WT_V Unroll on windowside: no
Dimensions - Area: 1.42301 m2; RSen_C_length: 1200 mm; Volume: 0.0321211 m3; WT_V Length: 1200 mm
Other - Category: Generic Models; Family: RSen_31_GM_FB_sunscreen - ducoscreen front 150_duco: fix - tube 78_duco_ducoscreen front 150; Family and Type: RSen_31_GM_FB_sunscreen - ducoscreen front 150_duco: fix - tube 78_duco_ducoscreen front 150; Schedule Level: Level: Level 1; Type: RSen_31_GM_FB_sunscreen - ducoscreen front 150_duco: fix - tube 78_duco_ducoscreen front 150; Type Id: RSen_31_GM_FB_sunscreen - ducoscreen front 150_duco: fix - tube 78_duco_ducoscreen front 150
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/duco

# IfcBuildingElementProxy: fix_duco_ducoscreen front 150 (2)
In: Level 1
Type - Classification: 30 (Uniformat); Material: RSen_h4_aluminium
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Construction(Type) - WT_V Fix: yes; WT_V Standard: no
Type - Dimensions(Type) - WT_V Depth: 110 mm; WT_V Width: 36 mm
Type - Identity Data(Type) - Assembly Code: 30; Description: conductor_fix_duco_ducoscreen front 150; Manufacturer: Duco; Model: DucoScreen Front 150; RSen_C_code_ETIM: Blinds; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC003229&classVersion=1; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 22/04/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V2; RSen_C_description: conductor_fix_duco_ducoscreen front 150; RSen_C_model: DucoScreen Front 150; RSen_C_revit_version: 2016; RSen_C_type: standard; RSen_C_type_comments: conductor; Type Comments: conductor; Type Name: fix_duco_ducoscreen front 150; URL: http://www.duco.eu/producten/; WT_I BaseKeynote: 31.2
Type - Other(Type) - Category: Generic Models; Family Name: RSen_31_GM_FB_conductor - SH_duco
Pset_BuildingElementProxyCommon - Reference: fix_duco_ducoscreen front 150
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Moves With Nearby Elements: no
Construction - WT_V Unroll on outside: yes; WT_V Unroll on windowside: no
Dimensions - RSen_C_length: 1200 mm; Volume: 0.000943131 m3
Materials and Finishes - RSen_C_material: RSen_h4_aluminium
Other - Category: Generic Models; Family: RSen_31_GM_FB_conductor - SH_duco: fix_duco_ducoscreen front 150; Family and Type: RSen_31_GM_FB_conductor - SH_duco: fix_duco_ducoscreen front 150; Type: RSen_31_GM_FB_conductor - SH_duco: fix_duco_ducoscreen front 150; Type Id: RSen_31_GM_FB_conductor - SH_duco: fix_duco_ducoscreen front 150
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/duco
Name (RSen_31_GM_FB_conductor - SH_duco:fix_duco_ducoscreen front 150:...)
209102
209103
